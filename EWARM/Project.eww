<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\MQ2.ewp</path>
  </project>
  <batchBuild />
</workspace>
